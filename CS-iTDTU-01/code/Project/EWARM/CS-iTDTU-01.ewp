# IAR project CS-iTDTU-01.ewp, settings and files
configuration CS-iTDTU-01 (ARM, debug)
  General.OGChipSelectEditMenu: STM32L071RZ ST STM32L071RZ
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32L071xx
  ICCARM.CCIncludePath2: ../Inc; ../Drivers/STM32L0xx_HAL_Driver/Inc; ../Drivers/STM32L0xx_HAL_Driver/Inc/Legacy; ../Drivers/CMSIS/Device/ST/STM32L0xx/Include; ../Drivers/CMSIS/Include; ../Inc/product/cs_itdt_01; ../service/ringbuffer; ../app/uart_ringbuffer; ../app/low_power_ctl; ..\app\common_interface; ../app/Communication; ../app/protocol; ../app/battery; ../app/protocol/product_protocol; ../service; ../Drivers/tim; ../Drivers/adc; ../Drivers/DUART; ../Drivers/NBIOT; ../Drivers/lorawan; ../Drivers/lptim; ../Drivers/usart; ../Drivers/gpio; ../Drivers/dma; ../Drivers/adc; ../service/character_convert; ..\EWARM; ..\Drivers\flash; ..\Drivers\LED; ..\app\IOChannelManage; ..\Drivers\RS485; ..\Drivers\musart; ..\Drivers\Key
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: CS-iTDTU-01.hex
  prebuild: cmd /c start svn_ver.bat $PROJ_DIR$
  ILINK.IlinkOutputFile: CS-iTVP-06.out
  ILINK.IlinkIcfFile: stm32l071xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32l071xx.s stm32l071xx_flash.icf stm32l071xx_sram.icf
  group Application/User
    ../Src/: main.c stm32l0xx_hal_msp.c stm32l0xx_it.c
    ../Inc/: stm32l0xx_hal_conf.h
  group Application/User/APP/battery
    ../app/battery/: battery.c
  group Application/User/APP/common_interface
    ../app/common_interface/: common_interface.c
  group Application/User/APP/Communication
    ../app/Communication/: communication.c
  group Application/User/APP/IOChannelManage
    ../app/IOChannelManage/: IOChannelManage.c
  group Application/User/APP/low_power_ctl
    ../app/low_power_ctl/: low_power_ctl.c
  group Application/User/APP/PROTOCOL
    ../app/protocol/: Protocol.c
  group Application/User/APP/PROTOCOL/product_protocol
    ../app/protocol/product_protocol/: product_protocol.c
  group Application/User/APP/SERVICE
    ../service/: SrvIODevice.c SrvIODeviceItem.c SrvList.c
  group Application/User/APP/SERVICE/character_convert
    ../service/character_convert/: character_convert.c
  group Drivers/adc
    ../Drivers/adc/: adc.c ADCDriver.c
  group Drivers/CMSIS
    ../Src/: system_stm32l0xx.c
  group Drivers/dma
    ../Drivers/dma/: dma.c
  group Drivers/DUART
    ../Drivers/DUART/: duart.c
  group Drivers/EEPROM
    ../Drivers/EEPROM/: EEPROM.c
  group Drivers/flash
    ../Drivers/flash/: Flash.c
  group Drivers/gpio
    ../Drivers/gpio/: gpio.c
  group Drivers/led
    ../Drivers/LED/: led.c led.h
  group Drivers/lorawan
    ../Drivers/LoraWan/: lorawan.c
  group Drivers/lptim
    ../Drivers/lptim/: lptim.c
  group Drivers/musart
    ../Drivers/musart/: musart.c
  group Drivers/NBIOT
    ../Drivers/NBIOT/: NBIOT.c
  group Drivers/RS485
    ../Drivers/RS485/: RS485.c
  group Drivers/STM32L0xx_HAL_Driver
    ../Drivers/STM32L0xx_HAL_Driver/Src/: stm32l0xx_hal.c stm32l0xx_hal_adc.c stm32l0xx_hal_adc_ex.c stm32l0xx_hal_cortex.c stm32l0xx_hal_dma.c stm32l0xx_hal_flash.c stm32l0xx_hal_flash_ex.c stm32l0xx_hal_flash_ramfunc.c stm32l0xx_hal_gpio.c stm32l0xx_hal_lptim.c stm32l0xx_hal_pwr.c stm32l0xx_hal_pwr_ex.c stm32l0xx_hal_rcc.c stm32l0xx_hal_rcc_ex.c stm32l0xx_hal_smbus.c stm32l0xx_hal_tim.c stm32l0xx_hal_tim_ex.c stm32l0xx_hal_uart.c stm32l0xx_hal_uart_ex.c
  group Drivers/tim
    ../Drivers/tim/: tim.c
  group Drivers/usart
    ../Drivers/usart/: usart.c
