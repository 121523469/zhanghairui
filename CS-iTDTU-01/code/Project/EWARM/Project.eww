<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\CS-iTDTU-01.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\..\..\..\..\PrivateCode\convert\code\project.ewp</path>
    </project>
    <batchBuild />
</workspace>
